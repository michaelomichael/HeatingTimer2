# Keil uVision project HeatingTimer.uvgui.uvproj, settings and files
target STM32F0-Discovery (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Test3 (deleteme) +hex
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX, USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\sys;.\inc;.\project_files;..\orzlib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --info=stack --callgraph
  group sys
    ./sys/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c arm_common_tables.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h startup_stm32f0xx.s stm32f0xx.h stm32f0xx_adc.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h system_stm32f0xx.h
  group project_files
    ./project_files/: main.cpp HeatingCommon.h HeatingESP8266.h WifiDetails.h Thermometer.cpp Thermometer.h BoilerController.cpp BoilerController.h
    ../OrzLib/: RTC.cpp RTC.h ESP8266.cpp ESP8266.h
    ./: HeatingESP8266.cpp
  group Unused
    ./project_files/: HeatingWifly.h HeatingUI.h HeatingUI.cpp
    ./: HeatingWifly.cpp
    ../OrzLib/: LiquidCrystal.h Encoder.cpp Encoder.h LiquidCrystal.cpp
  group Library files
    ./project_files/: stm32f0xx_it.c system_stm32f0xx.c main.h stm32f0xx_it.h stm32f0xx_conf.h
    ../OrzLib/: HardwareSerial.cpp Delay.h Print.cpp orz.cpp orz.h Delay.c Print.h HardwareSerial.h
